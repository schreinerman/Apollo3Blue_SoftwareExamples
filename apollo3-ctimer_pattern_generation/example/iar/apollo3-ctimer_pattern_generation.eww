<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\apollo3-ctimer_pattern_generation.ewp</path>
  </project>
  <batchBuild/>
</workspace>


