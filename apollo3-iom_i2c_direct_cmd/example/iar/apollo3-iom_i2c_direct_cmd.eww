<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\apollo3-iom_i2c_direct_cmd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


