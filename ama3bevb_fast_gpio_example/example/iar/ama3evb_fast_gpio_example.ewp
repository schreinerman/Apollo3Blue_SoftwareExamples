# IAR project ama3evb_fast_gpio_example.ewp, settings and files
configuration AMA3B1KK-KCR_Release (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APOLLO3_1024=1; APOLLO3_1024=1
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ama3evb_fast_gpio_example.srec
  ILINK.IlinkOutputFile: ama3evb_fast_gpio_example.out
  ILINK.IlinkIcfFile: config\ama3b1kk-kcr_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration AMA3B1KK-KCR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ILINK.IlinkIcfFile: config\ama3b1kk-kcr_ram.icf
configuration AMA3B1KK-KBR_Release (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ILINK.IlinkIcfFile: config\ama3b1kk-kbr_rom.icf
configuration AMA3B1KK-KBR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ILINK.IlinkIcfFile: config\ama3b1kk-kbr_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_apollo3.c
  group source
    ../source/: main.c
    ./: startup_apollo3.s
