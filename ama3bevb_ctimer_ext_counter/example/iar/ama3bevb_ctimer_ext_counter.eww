<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ama3bevb_ctimer_ext_counter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


