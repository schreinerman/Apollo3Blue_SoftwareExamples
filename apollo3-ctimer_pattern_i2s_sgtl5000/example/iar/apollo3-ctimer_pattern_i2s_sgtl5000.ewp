# IAR project apollo3-ctimer_pattern_i2s_sgtl5000.ewp, settings and files
configuration AMA3B1KK-KCR_Release (ARM, debug)
  General.OGChipSelectEditMenu: Ambiq Micro:120 AMA3B1KK-KCR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APOLLO3_1024=1; APOLLO3_1024=1
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: apollo3-ctimer_pattern_i2s_sgtl5000.srec
  ILINK.IlinkOutputFile: apollo3-ctimer_pattern_i2s_sgtl5000.out
  ILINK.IlinkIcfFile: config\ama3b1kk-kcr_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration AMA3B1KK-KCR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\ama3b1kk-kcr_ram.icf
configuration AMA3B1KK-KBR_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Ambiq Micro:120 AMA3B1KK-KBR
  ILINK.IlinkIcfFile: config\ama3b1kk-kbr_rom.icf
configuration AMA3B1KK-KBR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\ama3b1kk-kbr_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_apollo3.c
  group source
    ../source/: main.c
    ./: startup_apollo3.s
