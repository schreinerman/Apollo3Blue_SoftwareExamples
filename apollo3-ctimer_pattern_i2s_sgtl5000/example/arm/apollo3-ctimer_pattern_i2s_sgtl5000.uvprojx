# Keil uVision project apollo3-ctimer_pattern_i2s_sgtl5000.uvprojx, settings and files
target AMA3B1KK-KCR_Debug (ARM-ADS)
  device: AMA3B1KK-KCR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IROM(0xC000,0xF4000) IRAM1(0x10000000,0x5FFF0) CPUTYPE"(Cortex-M4")
  output: apollo3-ctimer_pattern_i2s_sgtl5000 +hex
  c flags: Optim=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel
  memory RVCT4: ROM 0x10000000 size 0x2FFF8
  memory RVCT9: RAM 0x1002FFF8 size 0x2FFF8
  group common
    ../../common/: system_apollo3.c
  group source
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_apollo3.s
target AMA3B1KK-KCR_Release (ARM-ADS)
  device: AMA3B1KK-KCR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: apollo3-ctimer_pattern_i2s_sgtl5000 +hex
  c flags: Optim=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1
  c include: as above
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x5FFF0
target AMA3B1KK-KBR_Debug (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: apollo3-ctimer_pattern_i2s_sgtl5000 +hex
  c flags: Optim=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1 APOLLO3_1024=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x2FFF8
  memory RVCT9: RAM 0x1002FFF8 size 0x2FFF8
target AMA3B1KK-KBR_Release (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: as above
  output: apollo3-ctimer_pattern_i2s_sgtl5000 +hex
  c flags: Optim=1
  c define: APOLLO3_1024=1 APOLLO3_1024=1
  c include: as above
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x5FFF0
